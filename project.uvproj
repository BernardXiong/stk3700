# Keil uVision project project.uvproj, settings and files
target rtthread-efm3 (ARM-ADS)
  device: EFM32GG990F1024 Energy Micro
  cpu: IRAM(0x20000000-0x2001FFFF) IROM(0-0xFFFFF) CLOCK(48000000) CPUTYPE("Cortex-M3")
  output: rtthread-efm32
  AfterMake: fromelf --bin !L --output rtthread.bin
  c flags: Optim=1
  c define: EFM32GG990F1024
  c include: .;Libraries\CMSIS\CM3\CoreSupport;Libraries\emlib\EFM32GG\Include;Libraries\emlib\inc;applications;drivers;rt-thread\components\drivers\include;rt-thread\components\finsh;rt-thread\include;rt-thread\libcpu\arm\common;rt-thread\libcpu\arm\cortex-m3
  memory RVCT4: ROM 0x0 size 0x100000
  memory RVCT9: RAM 0x20000000 size 0x20000
  link misc: --keep __fsym_* --keep __vsym_*
  group Applications
    applications/: application.c board.c startup.c userled.c
  group Drivers
    drivers/: drv_eint.c drv_led.c drv_uart.c
  group EFM32_StdPeriph
    Libraries/CMSIS/CM3/CoreSupport/: core_cm3.c
    Libraries/emlib/EFM32GG/Source/: system_efm32gg.c
    Libraries/emlib/src/: em_acmp.c em_adc.c em_aes.c em_assert.c em_burtc.c em_cmu.c em_dac.c em_dbg.c em_dma.c em_ebi.c em_emu.c em_gpio.c em_i2c.c em_int.c em_lcd.c em_lesense.c em_letimer.c em_leuart.c em_mpu.c em_msc.c em_opamp.c em_pcnt.c em_prs.c em_rmu.c em_rtc.c em_system.c em_timer.c em_usart.c em_vcmp.c em_wdog.c
    Libraries/emlib/EFM32GG/Source/ARM/: startup_efm32gg.s
  group Kernel
    rt-thread/src/: clock.c device.c idle.c ipc.c irq.c kservice.c mem.c mempool.c object.c scheduler.c thread.c timer.c
  group CORTEX-M3
    rt-thread/libcpu/arm/cortex-m3/: cpuport.c context_rvds.s
    rt-thread/libcpu/arm/common/: backtrace.c div0.c showmem.c
  group DeviceDrivers
    rt-thread/components/drivers/serial/: serial.c
    rt-thread/components/drivers/src/: completion.c dataqueue.c pipe.c portal.c ringbuffer.c
  group finsh
    rt-thread/components/finsh/: shell.c symbol.c cmd.c finsh_compiler.c finsh_error.c finsh_heap.c finsh_init.c finsh_node.c finsh_ops.c finsh_parser.c finsh_var.c finsh_vm.c finsh_token.c
